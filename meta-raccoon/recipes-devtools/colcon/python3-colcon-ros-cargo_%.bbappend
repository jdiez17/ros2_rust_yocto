FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-support-for-passing-a-Rust-target-to-ament_cargo.patch"

LICENSE = "CLOSED"

